# Keil uVision project boot.uvproj, settings and files
target boot (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: ..\..\..\src\bsp\platform\arm-m3-stm32l1xx\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\boot;..\..\..\src\boot\STM32L1xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp-platform
    ../../../src/bsp/platform/arm-m3-stm32l1xx/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group boot
    ../../../src/boot/STM32L1xx/: stm32l1xx_it.c system_stm32l1xx.c startup_stm32l1xx_mdp.s
    ../../../src/boot/: main.c usart.c common.c ymodem.c
