# Keil uVision project boot.uvprojx, settings and files
target boot (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: ..\..\..\src\bsp\platform\arm-m3-stm32l1xx\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\boot;..\..\..\src\boot\STM32L1xx;..\..\..\src\bsp\platform\arm-m3-stm32l1xx\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp-platform
    ../../../src/bsp/platform/arm-m3-stm32l1xx/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_iwdg.c
  group boot
    ../../../src/boot/STM32L1xx/: stm32l1xx_it.c system_stm32l1xx.c startup_stm32l1xx_mdp.s
    ../../../src/boot/: main.c usart.c common.c ymodem.c
