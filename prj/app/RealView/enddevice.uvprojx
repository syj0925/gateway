# Keil uVision project enddevice.uvprojx, settings and files
target enddevice (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: enddevice +hex
  AfterMake: .\afterbuild.bat
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: ..\..\..\src\bsp\platform\arm-m3-stm32l1xx\CMSIS\Include;..\..\..\src\bsp\platform\arm-m3-stm32l1xx\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\bsp\broad\STM32L1xx;..\..\..\src\bsp\broad;..\..\..\src\thirdparty\ioLibrary_Driver-master\Ethernet\W5500;..\..\..\src\thirdparty\ioLibrary_Driver-master\Internet\DHCP;..\..\..\src\thirdparty\ioLibrary_Driver-master\Ethernet;..\..\..\src\thirdparty\cm_backtrace;..\..\..\src\thirdparty\MQTTPacket\src;..\..\..\src\thirdparty\nRF240L01_net;..\..\..\src\my-os\os_mem;..\..\..\src\my-os\os_msg;..\..\..\src\my-os\os_timer;..\..\..\src\my-os\os_sys;..\..\..\src\my-util;..\..\..\src\my-mdl;..\..\..\src\my-drv\zigbee;..\..\..\src\my-drv\ethernet;..\..\..\src\my-drv\dali;..\..\..\src\my-drv\wifi;..\..\..\src\app;..\..\..\src\app\comm;..\..\..\src\app\alarm;..\..\..\src\app\general;..\..\..\src\app\sys_cfg;..\..\..\src\app\test;..\..\..\src\app\sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp-board
    ../../../src/bsp/broad/STM32L1xx/: system_stm32l1xx.c startup_stm32l1xx_mdp.s stm32l1xx_it.c
    ../../../src/bsp/broad/: usart.c bsp.c eeprom.c dimming.c adc.c spi_w5500.c i2c_ds1338.c nrf24l01.c
  group bsp-platform
    ../../../src/bsp/platform/arm-m3-stm32l1xx/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group lib-ethernet
    ../../../src/thirdparty/ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
    ../../../src/thirdparty/ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ../../../src/thirdparty/ioLibrary_Driver-master/Internet/DHCP/: dhcp.c
  group lib-backtrace
    ../../../src/thirdparty/cm_backtrace/: cm_backtrace.c
    ../../../src/thirdparty/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group lib-mqtt
    ../../../src/thirdparty/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group lib-nrf24l01net
    ../../../src/thirdparty/nRF240L01_net/: net_link.c net_link_node.c net_link_recv.c net_link_send.c
  group my-os
    ../../../src/my-os/os_timer/: os_timer.c
    ../../../src/my-os/os_mem/: mem.c
    ../../../src/my-os/os_msg/: os_msg.c
    ../../../src/my-os/os_sys/: os_systime.c
  group my-drv
    ../../../src/my-drv/ethernet/: drv_ethernet.c
    ../../../src/my-drv/dali/: drv_dali.c
    ../../../src/my-drv/zigbee/: drv_zigbee.c
    ../../../src/my-drv/wifi/: drv_esp8266.c
  group my-mdl
    ../../../src/my-mdl/: public_para_manager.c public_para_reg.c
  group my-util
    ../../../src/my-util/: debug.c dlist.c roundbuf.c stream.c utils.c sunset.c
  group app
    ../../../src/app/: main.c
    ../../../src/app/comm/: comm_manager.c comm_recv.c comm_send.c comm_protocol.c
    ../../../src/app/general/: energy_measure.c lamp_manager.c task_manager.c general_manager.c para_manager.c update.c debug_cmd.c
    ../../../src/app/alarm/: alarm_v_leakage.c alarm_turn_off_fault.c alarm_turn_on_fault.c alarm_manager.c
    ../../../src/app/test/: yeelink.c fault_test.c tts.c
    ../../../src/app/sensor/: wsn_sensor.c
